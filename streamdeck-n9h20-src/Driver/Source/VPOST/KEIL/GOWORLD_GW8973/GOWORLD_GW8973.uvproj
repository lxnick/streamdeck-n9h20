# Keil uVision project GOWORLD_GW8973.uvproj, settings and files
target N9H20_GOWORLD_GW8973 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H20_VPOST_GWGW8973 (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __HAVE_GOWORLD_GW8973__
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Src
    ../../: N9H20_VPOST.C N9H20_VPOST_Driver.c N9H20_VPOST_GOWORLD_GW8973.c
