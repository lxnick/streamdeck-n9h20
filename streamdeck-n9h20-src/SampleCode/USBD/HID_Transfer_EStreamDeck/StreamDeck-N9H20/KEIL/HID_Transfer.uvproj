# Keil uVision project HID_Transfer.uvproj, settings and files
target N9H20K5_HID_Transfer (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: HID_Transfer
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _KPI_NONBLOCK_
  c include: ..\..\..\..\..\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
  group Source Group
    ../: standalone.c wb_init.s main.c jpegDec.c
  group Lib
    ../../../../../Library/IPLib/: N9H20_VPOST_FW043TFT_480x272.lib N9H20_JPEG.lib N9H20_UDC.lib N9H20_SYS.lib N9H20_KPI_2x3.lib N9H20_GPIO.lib
    ../../../../../Driver/Source/VPOST/: N9H20_VPOST_FW050TFT_800x480.c
  group HID
    ../: HID.c
target N9H20K3_HID_Transfer (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: HID_Transfer
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K1_HID_Transfer (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: HID_Transfer
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\..\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\Script\N9H20K1\N9H20K1.sct
  link misc: --entry 0
